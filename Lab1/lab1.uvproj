# Keil uVision project lab1.uvproj, settings and files
target Lab1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: lab1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ../lib/common/inc, ../lib/_tm4c, ../lib/LCD/ST7735/inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
    ../lib/common/src/: PLL.c
    ../lib/_tm4c/: startup.s
    ../lib/LCD/ST7735/src/: ST7735.c
